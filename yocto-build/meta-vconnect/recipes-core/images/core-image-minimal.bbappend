#IMAGE_BOOT_FILES:append = " mys-6ull-14x14-gpmi-weim.dtb boot.scr"
IMAGE_BOOT_FILES = " \
    zImage \
    mys-6ull-14x14-gpmi-weim.dtb \
    tee.bin \
    uTee-6ullevk \
"
