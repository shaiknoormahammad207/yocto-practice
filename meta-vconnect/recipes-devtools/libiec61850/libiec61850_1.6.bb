require libiec61850.inc
BRANCH = "v1.6"
SRCREV = "a13961110b8238d2d8ea577c1fb7592ba3017ad8"

