require libiec61850.inc
BRANCH = "v1.1"
SRCREV = "0651b94be51d6e67fcb4a4fd89fdd2912e6a283e"

