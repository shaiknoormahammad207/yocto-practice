IMAGE_BOOT_FILES:append = " mys-6ull-14x14-gpmi-weim.dtb"
